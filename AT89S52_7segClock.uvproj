# Keil uVision project AT89S52_7segClock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: AT89S52_7segClock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 main.c delay.c display.c update.c port.c timer.c
  group Include
    ./: main.h delay.h display.h update.h port.h timer.h
